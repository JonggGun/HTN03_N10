# Keil uVision project AirQuality.uvprojx, settings and files
target AirQuality_F103C8 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AirQuality +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: STM32F103xB
  c misc: -std=c99 -ffunction-sections -fdata-sections
  c include: ..\bsp;..\app\inc;..\hal\inc;..\middlewares\FreeRTOS\include;..\middlewares\FreeRTOS\portable\GCC\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\air_quality.sct
  link misc: --entry=Reset_Handler
  group Application
    ../: main.c
    ../app/src/: air_logic.c app_ipc.c task_analysis.c task_display.c task_sensor.c
  group BSP
    ../bsp/: bsp.c startup.c
  group HAL
    ../hal/src/: hal_adc_gpio.c hal_i2c.c hal_oled.c hal_uart.c
  group FreeRTOS
    ../middlewares/FreeRTOS/: tasks.c queue.c list.c
    ../middlewares/FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ../middlewares/FreeRTOS/portable/MemMang/: heap_4.c
